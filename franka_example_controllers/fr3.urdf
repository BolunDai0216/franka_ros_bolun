Commit message: added pd_test_controller

File: franka_example_controllers/fr3.urdf (robot description, URDF)
Before this commit: robot fr3, 13 links, 12 joints
Links:
- link fr3_hand_tcp: mass 0.0 -> 1e-5
- link fr3_link8: mass 0.0 -> 1e-5
